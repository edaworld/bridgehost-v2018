# Keil uVision project BridgeHost.uvprojx, settings and files
target BridgeHost (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LoraMulti +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Source\UpDrive;.\Source\UserCode;.\Source\UserCode\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group UserCode
    ./Source/UpDrive/: bsp_task.c
    ./Source/UserCode/: main.c
  group UpDrive
    ./Source/UpDrive/: bsp.c bsp_led.c bsp_sx1276-LoRa.c bsp_rf.c
  group LowDrive
    ./Source/UpDrive/: bsp_systimer.c bsp_spi2.c bsp_timer.c bsp_uart_fifo.c bsp_uartpro.c
  group SysFile
    ./Source/UpDrive/: bsp_userlib.c bsp_tpc.c
  group 说明
    ./: 版本说明.txt
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
